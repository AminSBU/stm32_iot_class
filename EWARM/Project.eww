<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\01_STM32_Dadashi.ewp</path>
  </project>
  <batchBuild />
</workspace>
